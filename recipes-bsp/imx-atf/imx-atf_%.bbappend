#Assign ATF platform
ATF_PLATFORM := "imx8mq"
