# Copyright 2017-2022 NXP
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

require imx-mkimage_git.inc


ATF_MACHINE_NAME = "bl31-imx8mq.bin"