PACKAGECONFIG += " gstreamer alsa"
