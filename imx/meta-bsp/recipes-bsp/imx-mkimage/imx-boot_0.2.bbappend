FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
		file://0001-PICOITX-Added-the-DTB-for-the-picoitx.patch \
		"
